# Keil uVision project arm-stm407_discovery.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: arm-stm407_discovery +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\App\0_Common;.\App\1_Variation;.\App\2_Middle;.\App\3_Driver
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group 0_Common
    ./App/0_Common/: main.c discovery-kit.c
  group 1_Variation
    ./App/1_Variation/: app_init.c app_process.c
  group 2_Middle
    ./App/2_Middle/: clock.c gpio.c led.c
  group 3_Driver
    ./App/3_Driver/: arm_clock.c arm_flash.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
